# Keil uVision project Bootloader.uvprojx, settings and files
target Bootloader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55CGUx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: Bootloader +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32WB55xx
  c include: ../Core/Inc; ../Drivers/STM32WBxx_HAL_Driver/Inc; ../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32WBxx/Include; ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32wb55xx_flash_cm4.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: main.c stm32wbxx_it.c stm32wbxx_hal_msp.c
  group System
    ./Libraries/System/: System.c
  group uSD subsystem
    ./Libraries/System/uSD subsystem/: sd_override_functions.c uSD_driver_functions.c uSD_subsystem.c
  group TIM16 subsystem
    ./Libraries/System/TIM16 subsystem/: TIM16_driver_functions.c TIM16_subsystem.c
  group IHC
    ./Libraries/IntelHexConverter/: IHC.c
  group FatFs
    ./Libraries/FatFS_src/: diskio.c ff.c ffsystem.c ffunicode.c sdcard_if.c
  group Drivers/STM32WBxx_HAL_Driver
    ../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_spi.c stm32wbxx_hal_spi_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal.c stm32wbxx_hal_exti.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
software components: CMSIS:CORE 5.4.0
